;; main_menue_functions.inc
;; MAIN MENU JUMPTABLE
;; -----------------------


;; ----------[MAIN MENU SWITCH]------------------
;; -------------------------------------------
;; => CURRENT_MAIN_MENU = MAIN MENU SWITCH 

LABEL_MAIN_MENUE_SWITCH

	;; KEYBORAD: KEY HANDLING
	;; IF MAIN MENU KEY 
	;; IS = DEPRESSED (AY_KEY_STATE=1)
	;; THEN DO NOT EXECUTE A
	;; MAIN MENU FUNCTION
	movlw 	KEY_PRESSED_STATE_0	;; 0 = KEY PRESSED, 1 = DEPRESSED
	cpfseq 	SM_KEYB_KEY_STATE 	;; = 0?
		
		;; NO, Exit Here
		rgoto LABEL_MAIN_MENUE_SWITCH_EXIT

		;; YES
		rgoto LABEL_MAIN_MENUE_SWITCH_GO

LABEL_MAIN_MENUE_SWITCH_GO

	;; THE MAIN MENU WILL NOW BE PERFORMED
	;; NEXT CYCLE MUSST BE A SUB MENU CYCLE SO
	;; SET SUB MENU TO ACTIVE (for the next cycle!)
	movlw 	SWITCH_MAIN_MENU_OFF_SUB_MENU_ON_0x01	;; via 0x01
	movwf 	SWITCH_BETWEEN_MAIN_AND_SUBMENU 
	

	;; JUMP TO MAIN MENU [0-8]
	movf CURRENT_MAIN_MENU, W
	JUMPTABLE_4BYTES 9
		goto        	LABEL_AY_MAIN_MENU_00_MENU_SWITCH
		goto        	LABEL_AY_MAIN_MENU_01_PATCH_INFO_PREPARE
		goto        	LABEL_AY_MAIN_MENU_02_ABC_TUNE
		goto        	LABEL_AY_MAIN_MENU_03_ABC_MIXER
		goto 		LABEL_AY_MAIN_MENU_04_ABC_AMPLITUDE
		goto 		LABEL_AY_MAIN_MENU_05_ABC_ENVELOPE
		goto 		LABEL_AY_MAIN_MENU_06_MIDI_CONFIG
		goto 		LABEL_AY_MAIN_MENU_07_VELOCITY_CONFIG
		goto 		LABEL_AY_MAIN_MENU_08_FX
			 


LABEL_MAIN_MENUE_SWITCH_EXIT
	;; NEXT CYCLE MUSST BE A SUB MENU CYCLE SO
	;; SET SUB MENU TO ACTIVE
	movlw SWITCH_MAIN_MENU_OFF_SUB_MENU_ON_0x01	;; via 0x01
	movwf SWITCH_BETWEEN_MAIN_AND_SUBMENU 
	
		;; QUIT HERE
		return

;; -------------------------------------------

LABEL_AY_MAIN_MENU_01_PATCH_INFO_PREPARE
	
		;; NOW JUMP TO PATCH MAIN MENU
		goto LABEL_AY_MAIN_MENU_01_PATCH_INFO

;; ----------[MAIN MENU SWITCH END]--------








